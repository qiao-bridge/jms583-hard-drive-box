# Keil uVision project project.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC8G1K08 Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0x03FF) IROM(0-0x1FF8) CLOCK(35000000)
  output: project +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\02_stc8g_KEY;.\Bsp
  group Source
    ./: STARTUP.A51 main.c STC8G.H
  group Bsp
    ./Bsp/: stc8g_adc.c stc8g_adc.h stc8g_delay.c stc8g_delay.h stc8g_gpio.c stc8g_gpio.h stc8g_timer_pwm.c stc8g_timer_pwm.h stc8g_uart.c stc8g_uart.h stc8g_ntc_table.c stc8g_ntc_table.h stc8g_ws2812.c stc8g_ws2812.h
